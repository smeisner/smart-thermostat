# Repository smeisner/smart-thermostat

File README.md:

# Smart Thermostat

An open-source, high-integrity smart thermostat engineered to give **complete local control to the hardware owner**. This project combines custom physical hardware with a local-first software architecture to deliver predictive, intuitive HVAC management entirely independent of mandatory cloud ecosystems.

---

## 🧭 Core Philosophy

* **True Sovereignty:** The device firmware executes entirely on local hardware. It functions completely without mandatory internet-facing cloud sync, external tracking, or third-party background services.
* **System Integrity:** The entire system—encompassing both the custom physical PCB layer and the underlying firmware stack—is completely transparent, audit-ready, and entirely free of hidden telemetry or subversive data mining.
* **Intuitive Self-Sufficiency:** The on-device user interface is designed to be fully self-contained. End-users are never forced to parse terminal logs or inspect source code to diagnose system states; errors or unusual conditions are instantly translated into clear, actionable remedies right on the screen.

---

## ✨ Key Features

### Intelligent HVAC Automation
* **Context-Aware Comfort:** Adapts temperature setpoints dynamically based on localized weather forecasts.
* **Intelligent Ventilation:** Compares indoor air parameters against external conditions to suggest opening a window when ambient weather aligns with target comfort or when lower indoor air quality is detected.
* **Open-Structure Interlocking:** Automatically detects open doors or windows via ecosystem sensors and dynamically disables the active heating/cooling cycles to prevent energy waste.
* **Balancing & Predictive Maintenance:** Integrates remote temperature sensors to eliminate room-to-room temperature differentials and continuously monitors thermal rise/fall rate degradation to identify clogged air filters or mechanical service requirements.

### Connectivity & Control Layers
* **Local-First Ecosystems:** Built with native MQTT and Home Assistant integration for secure, local automation networking. Future milestones include native **Matter over Wi-Fi**.
* **Direct Administration:** Serves a robust, completely local configuration website for adjustments and provides secure Telnet/SSH management interfaces for localized diagnostic logs, debugging, and system metrics.
* **Hardware Interactivity:** Built around an elegant touchscreen user interface featuring zero mechanical face buttons, protected by a dedicated hardware master-reset circuit for ultimate fail-safe recovery.

---

## 🛠️ Hardware Specification

The physical platform is optimized for low power, clean power delivery, and transparent circuit execution.

* **MCU:** Espressif ESP32 (Dual Core, 240MHz, 4MB Flash) running entirely on a native **ESP-IDF** runtime environment. A dedicated On-Chip SWD interface is built-in for deep GDB hardware debugging and direct firmware loading.
* **Display & Touch:** 3.2" SPI TFT Display Module (ILI9341 driver paired with an XPT2046 touch controller). The UI layers and menu navigation frameworks are constructed using the open-source **LVGL (v8)** graphics library.
* **Power Regulation:** Built-in dual-stage industrial regulation translating standard 24VAC HVAC lines down to a ultra-low ripple (<2%) 5VDC rail via an LM2576HVT-5, regulated cleanly to a 3.3V digital rail via an AMS1117 LDO.
* **On-Board Sensor Arrays:**
  * **Climate:** Aosong AHT20 high-precision I2C Temperature & Humidity module.
  * **Presence:** Hi-Link LD2410 24GHz Microwave Radar Human Presence Sensor for localized wake-on-motion automation.
  * **Ambient:** Integrated Light Dependent Resistor (LDR) divider circuit for reactive, step-less TFT backlight dimming matching room conditions.

---

## 💻 Operating Environment & System Architecture

The core application runs deterministically under **FreeRTOS**. Resource allocation is strictly divided across priority-tiered tasks to keep the interface highly responsive:

| Task Name | Execution / Trigger | Priority tier | Purpose |
| :--- | :--- | :--- | :--- |
| `touch` | Hardware Interrupt (Low Touch Line) | Highest | Captures coordinates, processes UI input, triggers audible interface indicator. |
| `motion` | Hardware Interrupt (High Motion Line) | High | Updates human presence timestamps immediately upon radar detection. |
| `aht` | Deterministic (10-second intervals) | Medium-Low | Samples physical environmental sensor registers. |
| `state-machine` | Continuous (1-second loop pumping) | Lowest | Evaluates HVAC states, ticks safety timers, processes menu routing, maps reactive screen brightness via LDR readings, and sleeps the panel when the room is vacant. |

---

## 🤝 Contributing & Community Standards

We welcome engineering contributions from the open-source community! To maintain high code safety and absolute compliance with the project's vision, all contributors must align with our core repository governance:

1. **GPLv3 Compliance:** This project is proudly licensed under the **GNU General Public License, Version 3**. All downstream modifications, clones, or derivative software distributions must remain open, share identical copyleft freedoms, and must explicitly include complete installation information on consumer products.
2. **AI-Assisted Authorship Policy:** Code developed using AI tools is welcome. However, the human contributor assumes 100% accountability for the code. You must possess the complete technical capability to fully explain and defend every line, architectural choice, and flag during peer review.
3. **Compilation Warning Policy:** Code submissions should target a 100% clean compilation. If a specific compiler warning cannot be avoided due to legacy library quirks, it *must* be explicitly declared and technically justified in your Pull Request text for review by the Maintainers.
4. **Behavioral Code:** All interactions in our community tracking systems or communication channels are governed strictly by our **Contributor Covenant Code of Conduct**.

For details on setting up your compiler environment, partition schemes, or debugging crash logs via `esp-coredump`, please refer to our internal development wikis and the `CONTRIBUTING.md` guidelines.

## KiCad design pcb/Thermostat.kicad_pcb

Board: 4 copper layers, 101.5 x 83.4 mm, 92 parts (0 on the bottom side), 65 nets.

Parts:
BR1: MB6S; Diode_Bridge_Diotec_ABS
BZ1: Buzzer; Buzzer_TDK_PS1240P02BT_D12.2mm_H6.5mm
C1, C2, C7: 1uF; C_0603_1608Metric
C3, C14: 0.1uF; C_0603_1608Metric
C4: 22uF; C_0603_1608Metric
C5, C6: 22pF; C_0603_1608Metric
C8, C9, C15: 10uF; C_0603_1608Metric
C10, C11: 470uF; CP_Elec_10x10
C12: 47uF; CP_Elec_6.3x7.7
C13: 680uF; CP_Elec_16x17.5
D1: D_Zener; D_SMA
D2, D5, D6, D7: LED; LED_0805_2012Metric
D3: SP0502BAHT; SOT-23
D4: SS34; D_SMA
D8, D9, D10, D11, D12: 1N4148W; D_SOD-123
H1, H2, H3, H4, H5, H6, H7, H8, H9: MountingHole; MountingHole_2.7mm_M2.5
J1: USB_C_Receptacle_USB2.0; USB_C_Receptacle_G-Switch_GT-USB-7010ASV
J2: RC+RH; PinHeader_1x02_P2.54mm_Vertical
J3: Screw_Terminal_01x10; TerminalBlock_Phoenix_MPT-0,5-10-2.54_1x10_P2.54mm_Horizont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
J4: LD2410; PinSocket_1x05_P1.27mm_Vertical_SMD_Pin1Right
J5: UART PWR; PinHeader_1x02_P2.54mm_Vertical
J6: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J7: MSP3218; PinSocket_1x14_P2.54mm_Vertical
K1, K2, K3, K4, K5: UC2-3NJ; UC23NJ
L1: 600ohm; L_1206_3216Metric
L2: 470uH; IND_CDRH127_LDNP-470MC_SUM
Q1, Q2, Q3, Q4, Q5, Q6: 2N7002; SOT-23
R1, R2, R3, R4, R13, R14: 10k; R_0603_1608Metric
R5: 10K; R_0603_1608Metric
R6, R7: 5.1K; R_0603_1608Metric
R8, R10: 1K; R_0603_1608Metric
R9: 2K; R_0603_1608Metric
R11: 220; R_0603_1608Metric
R12: LDR07; R_LDR_5.1x4.3mm_P3.4mm_Vertical
R15: 1k; R_0603_1608Metric
R16, R17, R18, R19, R20: 470; R_0603_1608Metric
SW1: Reset; SW_SPST_TL3305A
SW2: Boot; SW_SPST_TL3305A
TP1: SCL; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP2: SDA; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP3: 3v3; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP4, TP4#2, TP4#3, TP4#4: +5V; TestPoint_THTPad_D2.0mm_Drill1.0mm
TP5: GND; TestPoint_THTPad_D2.0mm_Drill1.0mm
U1: ESP32-S3-WROOM-1-N16; XCVR_ESP32-S3-WROOM-1-N16R2
U2: LM2596T-5; TO-263-5_TabPin3
U3: AMS1117-3.3; SOT-223-3_TabPin2
U4: AHT20

Connections:
+3V3: C3.1, C4.1, C8.1, D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), K1.1 (COIL+), K2.1 (COIL+), K3.1 (COIL+), K4.1 (COIL+), K5.1 (COIL+), R1.2, R2.1, R3.1, R4.2, R11.2, R12.1, TP3.1, U1.2 (3V3), U3.2 (VO)
+5V: BZ1.1 (-), C9.1, C10.1, C11.1, C12.1, D1.1 (K), J4.5, J5.1, J7.1, L2.1, R13.2, TP4#3.1, U2.4 (FB), U3.3 (VI)
BUZZER: R15.1, U1.10 (IO17)
C: BR1.2, J3.10
E: J3.2, K3.4 (NO_1)
EN: C1.1, C2.1, R1.1, R4.1, SW1.2, U1.3 (EN)
G: J3.4, K4.4 (NO_1)
GND: BR1.4 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, D2.1 (K), D3.3 (A), D4.2 (A), D5.1 (K), D6.1 (K), D7.1 (K), J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J4.4, J6.4, J7.2, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), R6.2, R7.2, R14.1, SW1.1, SW2.1, TP5.1, U1.1 (GND), U1.40 (GND), U1.41_1 (GND), U1.41_2 (GND), U1.41_3 (GND), U1.41_4 (GND), U1.41_5 (GND), U1.41_6 (GND), U1.41_7 (GND), U1.41_8 (GND), U1.41_9 (GND), U1.41_10 (GND), U1.41_11 (GND), U1.41_12 (GND), U1.41_13 (GND), U1.41_14 (GND), U1.41_15 (GND), U1.41_16 (GND), U1.41_17 (GND), U1.41_18 (GND), U1.41_19 (GND), U1.41_20 (GND), U1.41_21 (GND), U2.3 (GND), U2.5 (~ON/OFF), U3.1 (GND), U4.5 (GND)
HVAC_2STAGE: R18.2, U1.32 (IO39)
HVAC_COOL: R17.2, U1.6 (IO6)
HVAC_FAN: R19.2, U1.4 (IO4)
HVAC_HEAT: R16.2, U1.5 (IO5)
HVAC_RVALV: R20.2, U1.7 (IO7)
LD_RX: J4.3, U1.8 (IO15)
LD_TX: J4.2, U1.9 (IO16)
LED_COOL: R10.2, U1.38 (IO2)
LED_FAN: R9.2, U1.30 (IO37)
LED_HEAT: R8.2, U1.31 (IO38)
LIGHT_SENS: R12.2, R14.2, U1.12 (IO8)
MOTION: J4.1, U1.11 (IO18)
unnamed: BR1.3 (+), C13.1, U2.1 (VIN)
unnamed: BZ1.2 (+), Q1.3 (D), R13.1
unnamed: C7.1, SW2.2, U1.27 (IO0)
unnamed: C14.1, C15.1, R11.1, U4.2 (VDD)
unnamed: D1.2 (A), L1.2
unnamed: D2.2 (A), R5.2
unnamed: D4.1 (K), L2.2, U2.2 (OUT)
unnamed: D5.2 (A), R8.1
unnamed: D6.2 (A), R9.1
unnamed: D7.2 (A), R10.1
unnamed: D8.2 (A), K1.8 (COIL-), Q2.3 (D)
unnamed: D9.2 (A), K2.8 (COIL-), Q3.3 (D)
unnamed: D10.2 (A), K3.8 (COIL-), Q4.3 (D)
unnamed: D11.2 (A), K4.8 (COIL-), Q5.3 (D)
unnamed: D12.2 (A), K5.8 (COIL-), Q6.3 (D)
unnamed: J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), L1.1, R5.1
unnamed: J1.A5 (CC1), R6.1
unnamed: J1.B5 (CC2), R7.1
unnamed: Q1.1 (G), R15.2
unnamed: Q2.1 (G), R16.1
unnamed: Q3.1 (G), R17.1
unnamed: Q4.1 (G), R18.1
unnamed: Q5.1 (G), R19.1
unnamed: Q6.1 (G), R20.1
O/B: J3.3, K5.4 (NO_1)
RC: J2.2, J3.8, K2.3 (COM_1)
RH: BR1.1, J2.1, J3.9, K1.3 (COM_1), K3.3 (COM_1), K4.3 (COM_1), K5.3 (COM_1)
RXD0: J6.2, U1.36 (RXD0)
SCL: R2.2, TP1.1, U1.28 (IO35), U4.3 (SCL)
SDA: R3.2, TP2.1, U1.29 (IO36), U4.4 (SDA)
TFT_CLK: J7.7, J7.10, U1.21 (IO13)
TFT_CS: J7.3, U1.17 (IO9)
TFT_DC: J7.5, U1.19 (IO11)
TFT_LED: J7.8, U1.22 (IO14)
TFT_MISO: J7.9, J7.13, U1.23 (IO21)
TFT_MOSI: J7.6, J7.12, U1.20 (IO12)
TFT_RESET: J7.4, U1.18 (IO10)
TOUCH_CS: J7.11, U1.24 (IO47)
TOUCH_IRQ: J7.14, U1.25 (IO48)
TXD0: J6.3, U1.37 (TXD0)
UART_VCC: J5.2, J6.1
USB_D+: C5.1, D3.1 (K), J1.A6 (D+), J1.B6 (D+), U1.14 (IO20)
USB_D-: C6.1, D3.2 (K), J1.A7 (D-), J1.B7 (D-), U1.13 (IO19)
W: J3.6, K1.4 (NO_1)
Y: J3.5, K2.4 (NO_1)

File pcb/thermostat-v0.6.0/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BR1,Diode_Bridge_Diotec_ABS,1,MB6S,C432636
C1,0603,1,1uF,C5673
"C10, C11",CP_Elec_10x10,2,470uF,C340751
C12,CP_Elec_6.3x7.7,1,47uF,C2164444
C13,CP_Elec_16x17.5,1,680uF,C401970
C14,0603,1,0.1uF,C14663
C15,0603,1,10uF,C96446
C2,0603,1,1uF,C5673
C3,0603,1,0.1uF,C14663
C4,0603,1,22uF,C86295
C5,0603,1,22pF,C1653
C6,0603,1,22pF,C1653
C7,0603,1,1uF,C5673
C8,0603,1,10uF,C96446
C9,0603,1,10uF,C96446
D1,D_SMA,1,D_Zener,C2480
"D10, D11, D12, D8, D9",D_SOD-123,5,1N4148W,C81598
D2,0805,1,LED,C108412
D3,SOT-23,1,SP0502BAHT,C207261
D4,D_SMA,1,SS34,C8678
D5,0805,1,LED,C130114
D6,0805,1,LED,C107402
D7,0805,1,LED,C108412
J1,USB_C_Receptacle_G-Switch_GT-USB-7010ASV,1,USB_C_Receptacle_USB2.0,C165948
J4,PinSocket_1x05_P1.27mm_Vertical_SMD_Pin1Right,1,LD2410,C2881514
L1,1206,1,600ohm,C108305
L2,IND_CDRH127_LDNP-470MC_SUM,1,470uH,C2453850
"Q1, Q2, Q3, Q4, Q5, Q6",SOT-23,6,2N7002,C8545
R1,0603,1,10k,C25804
R10,0603,1,1K,C21190
R11,0603,1,220,C22962
R13,0603,1,10k,C25804
R14,0603,1,10k,C25804
R15,0603,1,1k,C21190
R16,0603,1,470,C23179
R17,0603,1,470,C23179
R18,0603,1,470,C23179
R19,0603,1,470,C23179
R2,0603,1,10k,C25804
R20,0603,1,470,C23179
R3,0603,1,10k,C25804
R4,0603,1,10k,C25804
R5,0603,1,10K,C25804
R6,0603,1,5.1K,C415076
R7,0603,1,5.1K,C415076
R8,0603,1,1K,C21190
R9,0603,1,2K,C22975
SW1,SW_SPST_TL3305A,1,Reset,C2886902
SW2,SW_SPST_TL3305A,1,Boot,C2886902
TP1,TestPoint_THTPad_D2.0mm_Drill1.0mm,1,SCL,
TP2,TestPoint_THTPad_D2.0mm_Drill1.0mm,1,SDA,
TP3,TestPoint_THTPad_D2.0mm_Drill1.0mm,1,3v3,
"TP4_4, TP4_3, TP4_2, TP4",TestPoint_THTPad_D2.0mm_Drill1.0mm,4,+5V,
TP5,TestPoint_THTPad_D2.0mm_Drill1.0mm,1,GND,
U1,XCVR_ESP32-S3-WROOM-1-N16R2,1,ESP32-S3-WROOM-1-N16,C2913199
U2,TO-263-5_TabPin3,1,LM2596T-5,C41906
U3,SOT-223-3_TabPin2,1,AMS1117-3.3,C6186
U4,AHT20,1,AHT20,C3012622

## Code that names these connections

File app/include/gpio_defs.hpp:

#pragma once

//
// Define all the GPIO pins used
//

// HW Version 0.02

// #define LED_BUILTIN 2

// #define LED_HEAT_PIN 0
// #define BUZZER_PIN 4
// #define TOUCH_CS_PIN 5
// #define SWD_TDI_PIN 12
// #define SWD_TCK_PIN 13
// #define SWD_TMS_PIN 14
// #define TFT_CS_PIN 16
// #define HVAC_HEAT_PIN 17
// #define TFT_CLK_PIN 18
// #define HVAC_COOL_PIN 19
// #define TFT_LED_PIN 32
// #define TFT_RESET_PIN 33
// #define TFT_MISO_PIN 34
// #define TOUCH_IRQ_PIN 35
// #define LIGHT_SENS_PIN 36
// #define MOTION_PIN 39
// #define SDA_PIN 21
// #define SCL_PIN 22
// #define TFT_MOSI_PIN 23
// #define HVAC_FAN_PIN 25
// #define LED_COOL_PIN 26
// #define TFT_DC_PIN 27
// //#define LED_IDLE_PIN -1
// #define LED_IDLE_PIN 2

// HW Version 0.04

#define HVAC_FAN_PIN 4
#define HVAC_HEAT_PIN 5
#define HVAC_COOL_PIN 6
#define HVAC_RVALV_PIN 7
#define BUZZER_PIN 17
#define MOTION_PIN 18
#define LIGHT_SENS_PIN 8
#define TFT_CS_PIN 9
#define TFT_RESET_PIN 10
#define TFT_DC_PIN 11
#define TFT_MOSI_PIN 12
#define TFT_CLK_PIN 13
#define TFT_LED_PIN 14
#define LD_RX 15
#define LD_TX 16
#define TFT_MISO_PIN 21
#define TOUCH_CS_PIN 47
#define TOUCH_IRQ_PIN 48
#define SD_CS 40
#define SCL_PIN 35
#define SDA_PIN 36
#define LED_FAN_PIN 37
#define LED_HEAT_PIN 38
#define HVAC_STAGE2_PIN 39
#define GPIO41 41 //@@@ Not used
#define GPIO42 42 //@@@ Not used
#define LED_COOL_PIN 2

// #define SCL 35 //28
// #define SDA 36 //29

/*

Macros to convert GPIO number to ADC channel and vice versa

*/
#define _ADC_TO_GPIO(x) x##_GPIO_NUM
#define ADC_TO_GPIO(x) _ADC_TO_GPIO(x)
#define _GPIO_TO_ADC1(x) ADC1_GPIO##x##_CHANNEL
#define GPIO_TO_ADC1(x) _GPIO_TO_ADC1(x)
#define _GPIO_TO_ADC2(x) ADC2_GPIO##x##_CHANNEL
#define GPIO_TO_ADC2(x) _GPIO_TO_ADC2(x)

// Use some convoluted macro-magic to find the corresponding ADC for a specified GPIO
// Because ADCx_CHANNELx is n Enum, we can't use macro checks to verify which mapping is correct
//  Instead:
//    (1)  map GPIO->ADCx_GPIOy_CHANNEL : This will either result in an enum or an undefined macro
//    (2)  map (1) -> ADCx_CHANNEL_y_GPIO_NUM :
//         If (1) mapped to an enum, this will map back to a GPIO #
//         If (1) did NOT map to an enum, this will map to an empty value
//    (3)  compare (2) to the original GPIO which will only succeed if (1) mapped properly
#if (ADC_TO_GPIO(GPIO_TO_ADC1(CONFIG_BUTTON_INTR_PIN)) == CONFIG_BUTTON_INTR_PIN)
  #if (ADC_TO_GPIO(GPIO_TO_ADC1(CONFIG_GPIO_PIN)) == CONFIG_GPIO_PIN)
    #define CONFIG_ADC_CHAN GPIO_TO_ADC1(CONFIG_GPIO_PIN)
  #elif (ADC_TO_GPIO(GPIO_TO_ADC2(CONFIG_GPIO_PIN)) == CONFIG_GPIO_PIN)
    #define CONFIG_ADC_CHAN GPIO_TO_ADC2(CONFIG_GPIO_PIN)
  #else
    #error "No ADC found for CONFIG_GPIO_PIN"
    #define CONFIG_BUTTON_ADC_CHAN 0
  #endif
#endif

## Commit log (part)

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2023-02-10 Added Block Diagram.drawio
2023-02-10 Added Block Diagram.drawio.png
2023-02-11 Add KiCad files & Armbian NanoPi notes
2023-02-15 Working temp/humidity sensor
2023-02-15 Remove binary file
2023-02-21 Updated PCB/SCH - Add motion sensor, indicator lite, AHT20
2023-03-04 V0.01 sent to fab house
2023-03-04 Cleanup...add datasheets
2023-03-05 Updated 3D model
2023-03-05 Added source link
2023-03-05 Update datasheets
2023-03-12 First test version of ESP code
2023-03-13 New datasheets
2023-03-13 V0.01 - Prototype mostly working (RGB LED does not). Changes included for V0.02 prototype to correct problems.
2023-03-15 Add datasheet
2023-03-15 3D Modeling files
2023-03-15 Add BOM
2023-03-15 Add 'production' folder
2023-03-19 V0.02 - Updated README and app working (FreeRTOS, interrupts, touch int, motion int, read TP and AHT)
2023-03-19 V0.02 - Fixed README
2023-03-19 V0.02 - Add details to README
2023-03-19 V0.02 - Fixed README list spacing
2023-03-19 Update README.md
    Finally got list spacing correct!
2023-03-21 Major code reorg; Added wifi, web server (for updates)
2023-03-25 Web site working w/ updates; Added version info
2023-03-25 Enhanced motion detection/tracking
2023-03-26 Added note re: ESP32 SOC
2023-03-26 Improved web page & state machine logic
2023-04-01 Added data smoothing. Added EEPROM support. Properly set hostname.
2023-04-01 Added T&H sensor datasheets
2023-04-01 Added VSCode workspace file
2023-04-03 minor web page fixup
2023-04-03 Code reorg -- no code change; just reorg the files in the source repo
2023-04-03 Remove old NanoPi data files
2023-04-03 Cleaned up HVAC mode state transitions. Added temp range for AUTO
2023-04-03 Dropped AHT source file
2023-04-03 Dropped AHT header file
2023-04-04 updated .gitignore
2023-04-07 interim checkin for V0.03 prototype
2023-04-14 Add time sync via SNTP
2023-05-13 V0.2.0 : Addition of a UI (lvgl & SquareLine Studio) Additions of ntp & TZ support
2023-05-13 Fix minor UI bugs
2023-05-16 Auto-populate the UI dropdown
2023-05-19 v0.2.1 - Full UI
2023-05-19 v0.2.1 - Full UI - Including SquareLine Studio project files
2023-05-19 v0.2.1 - Full UI - SLS files
2023-05-19 Add lv_conf.h file after customizing.
2023-05-22 Updated README.md & moved lv_conf.h
2023-05-22 Added AHT20 info to README
2023-05-23 v0.3.0 - Added Celicius support; Improved TZ support; beep option; cleanup
2023-05-24 Track HVAC mode using internal values; Trying to get web server in RTOS task
2023-05-24 Add fractional part of current & set temp in web page
2023-05-24 Adding screenshots of SLS menus
2023-05-24 Update README.md
    Added screenshots of menus
2023-05-24 Reorganize png graphics for README.md
2023-05-25 v0.3.1 - Web server running as a task
2023-05-25 Added new config screen for less common parameters
2023-06-25 V0.4 - Update for V0.4 PCB (ESP32-S3) Stop converting temperatures; Drop the Adafruit lib for AHT; Add board definitons; Use task fro net reconnect
2023-06-26 Added details where this code (AHT20) was copied from
2023-06-26 Create 2 namespaces for the preferences data
2023-06-26 Show config info on startup
2023-06-26 Declare showConfigurationData globally
2023-06-26 Add config data dump routine
2023-06-26 Properly interpret the set temp and provide fractional part if in C
2023-06-26 New Getting Started doc
2023-06-26 Update Getting Started guide
2023-06-26 Add a bunch of new datasheets
2023-06-26 Added production files for V0.5.1
2023-06-26 Added sample output of doing a build inside a VM
2023-06-30 Update PCB files (v0.5.1)
2023-06-30 Moved getting started guide
2023-07-06 Update platformio.ini to use the latest ESP-IDF
2023-07-06 Remove app/test folder
2023-07-07 Add code doc around wifi credentials
2023-07-13 Removed stencil folder and small tweaks to PCB
2023-07-13 V0.5.2 PCB files exported as PDF
2023-07-13 Updated STL files to V0.5.2
2023-07-13 Corrected revision info
2023-07-13 Update GettingStarted.md
    Added BOM analysis sheet
2023-07-13 Updated model files for V0.5.2
2023-07-16 overhaul web ui
2023-07-29 Program the LD2410 on startup #14
2023-07-29 Remove need for wifi-credentials.h (store creds in NVRAM)
2023-08-05 Update README.md
    Updated info for LD2410 sensor
2023-08-05 Update README.md
    Updated to-do list
2023-08-17 Add proper code headers to cpp modules
2023-08-17 Update wifi module to use ESP-IDF. Also updated the time fetch to be less blocking.
2023-08-17 Update state_machine.cpp
    Changed attempt re-connect to every minute (was 30 seconds)
2023-08-28 Update web.cpp doc
    This iteration of the web.cpp code contains none of the XML code, I will add the proper notes and license notice when the final version of the XML code is committed.
2023-09-07 ESP-IDF rewrite - Stage 1
2023-09-07 ESP-IDF rewrite - Stage 2
2023-09-08 ESP-IDF rewrite - final touch ups
2023-09-08 Initial sdkconfig.esp32s3
2023-09-08 ESP-IDF conversion complete
2023-09-08 Update README.md
    Announce change to ESP-IDF
2023-09-08 sdkconfig.esp32-s3-devkitc-1 file added by mistake ... removing
2023-09-26 update web ui to live update
    Changes from arduino libraries to espressif libraries means
    some specifics have to change. This commit has no working buttons
    on the web ui, but all info like light, humidity, and temp readings
    are live.
2023-09-26 fix webui buttons
2023-09-27 make web ui indentation consistent
2023-09-28 add conditional rendering and more hvac controls
    Thermostat settings like fan, cool, and auto shouldn't be visible
    on the web ui if those options aren't available. These settings can
    now be toggled in the web ui and the corresponding buttons in the
    "Thermostat Controls" box won't be shown if they're not enabled.
2023-09-28 add temp swing and correction adjustments to webui
2023-09-28 add additional hvac system toggles to webui
    2 stage heating and reverse valve toggles
2023-09-28 add c/f unit toggle
2023-10-05 UI changes for MQTT and updated to 1.3.2 of SLS (Caused a lot of change)
2023-10-06 Safer xml buffer concatenation, license + author info
2023-10-16 0.7 - Use friendly name; improve screen UI (device name)
2023-10-23 Minor license and html adjustments
2023-10-24 Resynch w/ web pr. Improve MQTT connect
2023-10-26 Remove final printf and unused code.
2023-10-28 Updated diag message
2023-10-28 Fix typo
2023-10-28 ...more typos fixed
2023-11-03 Telnet server functional
2023-11-04 stats working in telnet CLI
2023-11-24 Use 1 version var, added telnet log monitoring & config, fixed control algorithm
2023-11-30 Add error struct, telnet control, eeprom updating
2023-12-01 add simple autobrightness
2023-12-02 Add support for telnet logging & wifi recovery
2023-12-02 Add ability to set timezone during telnet config
2023-12-02 turn on fan pin with heat or cool
2023-12-13 Fix multiple MONITOR commands; Fixed timezone validation
2023-12-15 Enable automatic MQTT reconnect
2023-12-18 V0.7.2 firmware
2023-12-18 v0.7.2 update
2023-12-29 Add motion sensor for MQTT, hvac state routine, cleaned MQTT module. Fixed fan state
2024-01-01 Limit MQTT updates to only if we're connected
2024-01-02 Send initial state of motion sensor
2024-01-21 Added telnet reset function to also restart service task
2024-02-01 Fixed server socket compare
2024-02-01 PCB V0.6.0
2024-02-01 Cleanup
2024-02-01 Cleanup whitespace
2024-02-01 File org cleanup
2024-02-01 More cleanup
2024-02-08 Changes due to new PCB
    With V0.6.0 PCB rev, there are a few changes in the code.
    - New 2nd stage relay
    - Removed SWD port
    - Changed RGB LED to SMD components
    Also added error recovery when AHT sensor doesn't respond.
2024-03-04 Updated GettingStarted guide
2024-03-10 Update GettingStarted.md
    Corrected a few minor mistakes.
2024-03-10 Update GettingStarted.md
    ...more small fixes
2024-03-24 Minor updates
2024-04-06 Call out IDF version problem
2024-04-12 Add MqttReconnect() func and clean up tracking of telnet sockets
2024-04-28 streamline HVAC_MODE string handling
    Remove unnecessary duplicated strings, by keeping them mode strings in an array.
    No functional changes.
2024-04-29 streamline the state-machine code
    Reduce duplicated code by initializing an array describing the GPIO
    pin states for each mode set by the state-machine.
2024-04-29 Fixed mem leaks esp in mqtt, telnet and wifi. Added heap reporting. General code cleanup
2024-04-30 Removed dead code and cleaned up log levels
2024-04-30 Changed 'company' name
2024-04-30 Updated package version numbers
2024-04-30 Corrected print statement for heap stats
2024-05-06 GettingStarted: reorg file and add Fedora instructions
    This commit perform some file reorganization:
    * Fix typos throughout the file
    * Change ordered lists to heading level
    * Use real markdown callouts for notes and warnings
    * Change inline code blocks to major code blocks
    * Use collapsible boxes distro-specific instructions
2024-05-06 further streamline the state-machine code
2024-05-30 Add v0.6.0 STL files
2024-07-22 actions: build firmware
2024-07-24 test
2024-08-09 Allow setting timezone from geo IP location
2024-08-09 Updated STEP file name
2024-08-13 Fix problem with timezone ordering
2024-09-12 Use function name in GEO IP timezone debug messages
2024-10-03 3D UWP case for prototype
2024-10-03 Moved files
2024-11-26 coice -> choice
2024-11-26 th elogging -> the logging
2024-11-26 soem -> some
2024-11-26 statemachine -> state machine
2024-11-26 sicne -> since
2024-11-26 Sudio -> Studio
2024-11-26 MQT -> MQTT
2024-11-26 Ths -> This
2024-11-26 back light -> backlight
2024-11-26 wifi -> Wifi
    Standardize to the same 'Wifi' in writing.
2024-11-26 Wifi -> WiFi
    Propose aligning to WiFi across document.
2025-02-26 Update wifi.cpp - fix scan function
    Swapped two lines to avoid the AP count to not be reset during a scan.
2025-03-03 Create InitialSetup.md
    Add documentation for steps to initially set up wifi, the device name and MQTT.
2025-03-03 Update InitialSetup.md
    Updated details on how to change the MQTT port
2025-03-06 modified: app/src/eeprom.cpp
2025-03-06 modified: app/src/wifi.cpp modified: app/src/eeprom.cpp
2025-03-08 Set running log level to WARN
2025-03-08 Avoid favicon not found error
2025-03-08 Display ld2410 fw, detect time changes
2025-03-08 Properly detect when we need to restart wifi
2025-03-08 Add '?' for help, LD2410 fw, better heap info, log level. Also, do proper socket cleanup
2025-03-08 Clear wifi scan active flag when Cancel clicked
2025-03-09 Fix issue #69 - Save HVAC params to NVS
2025-03-09 V0.8.0: Remove unused code; allow for proper MQTT state names; Update NVS even with web & screen changes
2025-03-09 V0.8.0: Major overhaul for wifi. Fix scanning; Better tracking of states & error recovery
2025-03-10 Change fw version to 0.8.0
2025-03-18 Fixed socket leak when AP connection is lost
2025-04-13 Migrate to LVGL9, remove UI, initial UI mockup
2025-04-19 Implemnet menus
2025-04-20 Finish menuing and integraton with thermostat
2025-04-20 Update framework-espidf version
2025-04-20 Fix OOM issue. Inscease platform memory. Enable auto-brightness
2025-04-20 Fix ssid entry
2025-04-20 Fix Calibration NVS
2025-04-21 Pin ld2410 library to 0.1.3 becasue 0.1.4 is broken, and 0.1.5 is not yet released in platformio
2025-04-22 Increase ssid size to 33 to match esp-idf. Add more paranoia to ensure all strings are null terminated. Fixes buffer overflow when setting long SSID
2025-04-22 Fix crash due to callback called from wrong thread
2025-04-22 Fix crash while scanning if ssid is correct, but password is wrong
2025-04-22 Simple fix for wrong log value
2025-04-22 Moved PCB design and data sheets to a separate repo
2026-01-02 Increase maximum length for WiFi SSID and password
    SSIDs can be 32 characters, WPA2 passwords can be 63 characters
2026-03-11 Updated some default values, fixed wifi management and scanning. Fixed a bug with touchscreen not working sometimes.
2026-03-11 sdkconfig changes required for HTTPS requests
2026-03-11 Fixed problem where initial wifi connect fails on first attempt.
2026-06-02 Version 0.8.2 - Enable SD card support - Enable core dump to SD - Implement multi level logging - Save config to SD card @ startup
2026-06-02 Add core dump analysis example to README
    Added example command for analyzing core dumps.
